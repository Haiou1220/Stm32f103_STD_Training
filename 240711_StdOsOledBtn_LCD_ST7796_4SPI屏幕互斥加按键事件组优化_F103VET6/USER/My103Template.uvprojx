# Keil uVision project My103Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: My103Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\FreeRTOS\portable\RVDS\ARM_CM3;..\FreeRTOS\include;..\FreeRTOS;..\HARDWARE\i2c;..\HARDWARE\oled;..\HARDWARE\key;..\HARDWARE\print;..\HARDWARE\usart;..\HARDWARE\led;..\HARDWARE\st7796;..\HARDWARE\spi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS_CORE
    ../FreeRTOS/: tasks.c queue.c list.c event_groups.c croutine.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group README
    ../: README.TXT
  group HARDWARE
    ../HARDWARE/i2c/: i2c.c
    ../HARDWARE/oled/: ssd1306.c font.c
    ../HARDWARE/key/: key.c key_app.c key_button.c
    ../HARDWARE/print/: print.c
    ../HARDWARE/usart/: usart.c usart_app.c
    ../HARDWARE/led/: led.c
    ../HARDWARE/st7796/: st7796_app.c st7796.c
    ../HARDWARE/spi/: spi.c
